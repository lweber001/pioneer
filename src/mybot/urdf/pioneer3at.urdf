Commit message: final work

File: src/mybot/urdf/pioneer3at.urdf (robot description, URDF)
Before this commit: robot pioneer3at, 17 links, 16 joints
Joints:
- joint hokuyo_joint: origin xyz=.21 0 .01 rpy=0 0 0 -> xyz=0.2 0 0.01 rpy=0 0 0
